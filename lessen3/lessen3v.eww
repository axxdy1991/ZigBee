<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lessen3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


